IMAGE_INSTALL:append = " rauc"
IMAGE_INSTALL:append = " e2fsprogs"

WKS_FILE = "ea-image-base.wks.in"

